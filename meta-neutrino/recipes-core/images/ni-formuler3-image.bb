require ni-formuler-image.bb

SUMMARY = "NI Neutrino image for Formuler F3"
COMPATIBLE_MACHINE = "^formuler3$"
