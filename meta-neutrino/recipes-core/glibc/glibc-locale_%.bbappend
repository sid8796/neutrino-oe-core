# Generate only the system locales required by the F3 image.
GLIBC_GENERATE_LOCALES = "en_US.UTF-8 ru_RU.UTF-8"
